options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: frequency_carrier
  id: variable
  parameters:
    value: 5760e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2 * bandwidth
  states: {}
- name: NTSC_decoder_c_0
  id: NTSC_decoder_c
  parameters:
    samp_rate: samp_rate
  states: {}
- name: NTSC_video_stream_converter_c_0
  id: NTSC_video_stream_converter_c
  parameters:
    decimation_factor: samp_rate / (360 *240 * 60)
    samp_rate: samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*850000000/8.0)
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e6
    win: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: '50'
    center_freq0: frequency_carrier
    center_freq1: frequency_carrier
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '50'
    gain1: '1000'
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: 240 * 2
    display_width: 360 * 2
    fps: '0'
    height: '240'
    type: short
    width: '360'
  states: {}

connections:
- [NTSC_decoder_c_0, '0', NTSC_video_stream_converter_c_0, '0']
- [NTSC_decoder_c_0, '1', NTSC_video_stream_converter_c_0, '1']
- [NTSC_decoder_c_0, '2', NTSC_video_stream_converter_c_0, '2']
- [NTSC_decoder_c_0, '3', NTSC_video_stream_converter_c_0, '3']
- [NTSC_video_stream_converter_c_0, '0', video_sdl_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', NTSC_decoder_c_0, '0']
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '1', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
